# Keil uVision project fwd_AdvancedEmbedded_Project1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GE6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fwd_AdvancedEmbedded_Project1.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\COTS\Libraries;..\COTS\Hal;..\COTS\Application;..\COTS\Mcal\Inc;..\COTS\Application
  asm include: ..\COTS\Hal;..\COTS\Libraries;..\COTS\Mcal\Inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    F:/ASUFE/Postgraduate/Learning_Courses/FWD Embedded Systems Advanced Track/Codes/_workspace/MotazKaoud-fwdAdvancedEmbedded-Project1/fwd project 1 repo/Code/COTS/Mcal/: Gpio_Dio.c Gpio_Port.c SysTick_Timer.c
  group Application
    F:/ASUFE/Postgraduate/Learning_Courses/FWD Embedded Systems Advanced Track/Codes/_workspace/MotazKaoud-fwdAdvancedEmbedded-Project1/fwd project 1 repo/Code/COTS/Application/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
