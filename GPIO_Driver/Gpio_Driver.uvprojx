# Keil uVision project Gpio_Driver.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GE6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gpio_Driver.axf +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Src\Mcal\Inc;..\Src\Config;..\Src\Common
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    ../Src/Mcal/: Gpio_Dio.c Gpio_Port.c Gpio_Types.c SysTick_Timer.c
  group Appl
    ../Src/Appl/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
